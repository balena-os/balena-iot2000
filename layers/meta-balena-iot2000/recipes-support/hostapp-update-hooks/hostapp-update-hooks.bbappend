HOSTAPP_HOOKS_append = " 99-resin-grub"
