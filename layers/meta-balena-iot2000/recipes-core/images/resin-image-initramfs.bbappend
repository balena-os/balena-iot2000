IMAGE_ROOTFS_MAXSIZE = "12300"
